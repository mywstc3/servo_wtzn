# Keil uVision project Blinky.uvprojx, settings and files
target GD32F150C8 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:LED 3.0.1, Device:GD32F1x0_StdPeripherals:GPIO 3.0.1, Device:GD32F1x0_StdPeripherals:MISC 3.0.1, Device:GD32F1x0_StdPeripherals:RCU 3.0.1, Device:GD32F1x0_libopt 3.0.1, Device:Startup 3.0.1
