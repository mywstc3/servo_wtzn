# Keil uVision project Blinky.uvprojx, settings and files
target GD32F150C8 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0-Beta4\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target GD32F150C8 RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.0.2
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
software components: CMSIS:CORE 4.3.0, Board Support:Buttons 3.0.1, Board Support:LED 3.0.1, Device:GD32F1x0_StdPeripherals:GPIO 3.0.1, Device:GD32F1x0_StdPeripherals:MISC 3.0.1, Device:GD32F1x0_StdPeripherals:RCU 3.0.1, Device:GD32F1x0_libopt 3.0.1, Device:Startup 3.0.1
