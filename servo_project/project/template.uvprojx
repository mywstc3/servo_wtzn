# Keil uVision project template.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: GD32F130F8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F130_150
  c include: ..\CMSIS;..\Library\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: system_gd32f1x0.c
  group Startup
    ../Startup/: startup_gd32f1x0.s
  group Library
    ../Library/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group User
    ../User/: main.c systick.c gd32f1x0_it.c
  group bsp
    ../User/bsp/: bap_i2c.c bap_uart.h bsp_adc.c bsp_adc.h bsp_gpio.c bsp_gpio.h bsp_i2c.h bsp_pwm.c bsp_pwm.h bsp_uart.c bsp_dma.c bsp_dma.h
  group servo
    ../User/servo/: Init.c init.h motor.c motor.h pid.c pid.h time.c time.h uart.c uart.h data_send.c data_send.h electricity.c electricity.h servo_config.c servo_config.h encoder.c encoder.h speed.c speed.h motor_test.c motor_test.h
